# Keil uVision project GameSimulation_0.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: GameSimulation_0 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 Delay.c key.c main.c music.c note.c oled.c oledfont.c systemstate.c Delay.h key.h music.h note.h oled.h oledfont.h systemstate.h
