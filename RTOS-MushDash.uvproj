# Keil uVision project RTOS-MushDash.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: RTOS-MushDash +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c RTX51TNY.h RTX51TNY.LIB oled12864.c oled12864.h oledfont.h Beep.h Delay.c Delay.h Timer0.c Timer0.h AT24C1024B.c AT24C1024B.h bmp.h Game.c Game.h key.c key.h menu.c menu.h Musictable.h Systemstate.c Systemstate.h Timer1.c Timer1.h
